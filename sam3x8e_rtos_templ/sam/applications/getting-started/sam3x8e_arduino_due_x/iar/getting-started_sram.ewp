# IAR project getting-started_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8E Atmel ATSAM3X8E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __SAM3X8E__; ARM_MATH_CM3=true; BOARD=ARDUINO_DUE_X
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ..; ../../../../utils/preprocessor; ../../../../drivers/pmc; ../../../../utils/cmsis/sam3x/source/templates; ../../../../../common/services/serial; ../../../../utils/cmsis/sam3x/include; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../drivers/uart; ../../../../../common/services/gpio; ../..; ../../../../utils; ../../../../drivers/tc; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; ../../../../boards/arduino_due_x; .; ..\..\..\..\..\freertos\include; ..\..\..\..\..\freertos\portable; ..\..\..\..\..; ..\..\..\..\drivers\trng; ..\..\..\..\drivers\smc; ..\..\..\..\components\ili93xx; ..\..\..\..\components\ili93xx\module_config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3X8E__; ARM_MATH_CM3=true; BOARD=ARDUINO_DUE_X
  AARM.AUserIncludes: ../../../../../common/services/serial/sam_uart; ..; ../../../../utils/preprocessor; ../../../../drivers/pmc; ../../../../utils/cmsis/sam3x/source/templates; ../../../../../common/services/serial; ../../../../utils/cmsis/sam3x/include; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../drivers/uart; ../../../../../common/services/gpio; ../..; ../../../../utils; ../../../../drivers/tc; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; ../../../../boards/arduino_due_x; .; ../../../../..
  OBJCOPY.OOCOutputFile: getting-started_sram.bin
  ILINK.IlinkOutputFile: getting-started_sram.out
  ILINK.IlinkIcfFile: E:\cortex-m3\sam3x8e_rtos_templ\linker_script\sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ..; ../../../../utils/preprocessor; ../../../../drivers/pmc; ../../../../utils/cmsis/sam3x/source/templates; ../../../../../common/services/serial; ../../../../utils/cmsis/sam3x/include; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../drivers/uart; ../../../../../common/services/gpio; ../..; ../../../../utils; ../../../../drivers/tc; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; ../../../../boards/arduino_due_x; .
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam3x/sam3x8/iar/sram.icf
  group common/boards
    ../../../../../common/boards/: board.h
  group common/services/clock
    ../../../../../common/services/clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/sam3x
    ../../../../../common/services/clock/sam3x/: genclk.h osc.h pll.h sysclk.c sysclk.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/serial
    ../../../../../common/services/serial/: serial.h usart_serial.c
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/utils
    ../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group freertos
    ../../../../../freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../freertos/portable/: heap_4.c port.c portasm.s
  group sam/applications/getting-started
    ../../: main.c
  group sam/applications/getting-started/sam3x8e_arduino_due_x
    ../: conf_board.h conf_clock.h conf_uart_serial.h
  group sam/applications/getting-started/sam3x8e_arduino_due_x/iar
    ./: asf.h
  group sam/boards/arduino_due_x
    ../../../../boards/arduino_due_x/: arduino_due_x.h init.c
  group sam/drivers/components/tft
    ../../../../components/ili93xx/module_config/: conf_ili93xx.h
    ../../../../components/ili93xx/: ili9325_regs.h ili9341_regs.h ili93xx.c ili93xx.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio.c pio.h pio_handler.c pio_handler.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: pmc.c pmc.h sleep.c sleep.h
  group sam/drivers/smc
    ../../../../drivers/smc/: smc.c smc.h
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group sam/drivers/trng
    ../../../../drivers/trng/: trng.c trng.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3x/include
    ../../../../utils/cmsis/sam3x/include/: sam3a4c.h sam3a8c.h sam3x4c.h sam3x4e.h sam3x8c.h sam3x8e.h sam3x8h.h sam3xa.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../utils/cmsis/sam3x/include/component/: component_adc.h component_can.h component_chipid.h component_dacc.h component_dmac.h component_efc.h component_emac.h component_gpbr.h component_hsmci.h component_matrix.h component_pdc.h component_pio.h component_pmc.h component_pwm.h component_rstc.h component_rtc.h component_rtt.h component_sdramc.h component_smc.h component_spi.h component_ssc.h component_supc.h component_tc.h component_trng.h component_twi.h component_uart.h component_uotghs.h component_usart.h component_wdt.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../utils/cmsis/sam3x/include/instance/: instance_adc.h instance_can0.h instance_can1.h instance_chipid.h instance_dacc.h instance_dmac.h instance_efc0.h instance_efc1.h instance_emac.h instance_gpbr.h instance_hsmci.h instance_matrix.h instance_pioa.h instance_piob.h instance_pioc.h instance_piod.h instance_pioe.h instance_piof.h instance_pmc.h instance_pwm.h instance_rstc.h instance_rtc.h instance_rtt.h instance_sdramc.h instance_smc.h instance_spi0.h instance_spi1.h instance_ssc.h instance_supc.h instance_tc0.h instance_tc1.h instance_tc2.h instance_trng.h instance_twi0.h instance_twi1.h instance_uart.h instance_uotghs.h instance_usart0.h instance_usart1.h instance_usart2.h instance_usart3.h instance_wdt.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../utils/cmsis/sam3x/include/pio/: pio_sam3a4c.h pio_sam3a8c.h pio_sam3x4c.h pio_sam3x4e.h pio_sam3x8c.h pio_sam3x8e.h pio_sam3x8h.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../utils/cmsis/sam3x/source/templates/: exceptions.c exceptions.h system_sam3x.c system_sam3x.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
